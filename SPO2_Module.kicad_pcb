# Repository Ruthvik3414/SPO2_Module_PCB_Design

File README.md:

# SpO2 Monitoring Module PCB Design (KiCad)

## Project Overview
This project involves the design of a SpO2 monitoring module PCB using KiCad. The PCB interfaces MAX30102 SpO2 sensor and SSD1306 OLED display with Arduino Nano using I2C communication.

---

## Schematic Design

---

## PCB Layout

---

## 3D View

---

## Features
- MAX30102 SpO2 Sensor Interface
- SSD1306 OLED Display Interface
- Arduino Nano Interface
- Push Buttons (Menu, Up, Down)
- LED Indicator
- I2C Communication
- 2 Layer PCB

---

## Tools Used
- KiCad
- ERC & DRC
- Gerber Generation

---

## Author
Ruthvik R

## KiCad design SPO2_Module.kicad_pcb

Board: 2 copper layers, 76.0 x 49.0 mm, 14 parts (0 on the bottom side), 9 nets.

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
ALARM: LED; LED_D5.0mm
C1, C2, C3: 100n; C_Disc_D4.7mm_W2.5mm_P5.00mm
DOWN: SW_Push; SW_PUSH_6mm
MENU: SW_Push; SW_PUSH_6mm
R1, R2, R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: MAX30102; MAX30102_MODULE
U2: SSD1306
UP: SW_Push; SW_PUSH_6mm

Connections:
+5V: A1.27 (+5V), R1.1, R2.1, R3.1, U1.5 (VCC), U2.2 (VCC)
GND: A1.4 (GND), A1.29 (GND), ALARM.1 (K), C1.2, C2.2, C3.2, DOWN.1, MENU.1, U1.4 (GND), U2.1 (GND), UP.1
unnamed: A1.23 (A4), U1.2 (SDA), U2.4 (SDA)
unnamed: A1.24 (A5), U1.3 (SCL), U2.3 (SCL)
unnamed: A1.5 (D2), C1.1, MENU.2, R1.2
unnamed: A1.6 (D3), C2.1, R2.2, UP.2
unnamed: A1.7 (D4), C3.1, DOWN.2, R3.2
unnamed: A1.15 (D12), R4.1
unnamed: ALARM.2 (A), R4.2

## Commit log

2026-03-25 README.md
